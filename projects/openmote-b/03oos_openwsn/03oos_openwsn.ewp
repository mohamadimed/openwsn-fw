# IAR project 03oos_openwsn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\common\; ..\..\..\bsp\chips\si70x\; ..\..\..\bsp\chips\at86rf215\; ..\..\..\bsp\chips\cc2538rf\; ..\..\..\kernel\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\openstack\; ..\..\..\openstack\OpenwsnHeads\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openstack\cross-layers\; ..\..\..\openapps\; ..\..\..\openapps\c6t\; ..\..\..\openapps\cexample\; ..\..\..\openapps\cmonitor\; ..\..\..\openapps\cinstrument\; ..\..\..\openapps\cinfo\; ..\..\..\openapps\cjoin\; ..\..\..\openapps\cleds\; ..\..\..\openapps\csensors\; ..\..\..\openapps\cwellknown\; ..\..\..\openapps\opencoap\; ..\..\..\openapps\uecho\; ..\..\..\openapps\cstorm\; ..\..\..\openapps\rrt\; ..\..\..\openapps\uinject\; ..\..\..\openapps\ugateway\; ..\..\..\openapps\uexpiration\; ..\..\..\openapps\uexpiration_monitor\; ..\..\..\openapps\userialbridge\; ..\..\..\bsp\boards\openmote-b\; ..\..\..\bsp\boards\openmote-b\headers\; ..\..\..\bsp\boards\openmote-b\source\; ..\..\..\projects\common\03oos_openwsn
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 03oos_openwsn.hex
  ILINK.IlinkOutputFile: 03oos_openwsn.out
  ILINK.IlinkIcfFile: ..\..\..\bsp\boards\openmote-b\cx2538xf53.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h
  group bsp/boards
    ../../../bsp/boards/: board.h cryptoengine.h debugpins.h eui64.h i2c.h leds.h radio.h sctimer.h spi.h toolchain_defs.h uart.h
  group bsp/boards/openmote-b
    ../../../bsp/boards/openmote-b/: adc_sensor.c adc_sensor.h board.c board_info.h cc2538rf.h cryptoengine.c debugpins.c eui64.c i2c.c leds.c radio.c sctimer.c sensors.c spi.c startup_iar.c uart.c
  group bsp/boards/openmote-b/headers
    ../../../bsp/boards/openmote-b/headers/: hw_aes.h hw_ana_regs.h hw_cctest.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_i2cm.h hw_i2cs.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_pka.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_soc_adc.h hw_ssi.h hw_sys_ctrl.h hw_types.h hw_uart.h hw_udma.h hw_udmachctl.h hw_usb.h
  group bsp/boards/openmote-b/source
    ../../../bsp/boards/openmote-b/source/: adc.c adc.h aes.c aes.h bl_commands.h ccm.c ccm.h cpu.c cpu.h debug.c debug.h ecc_curveinfo.h flash.c flash.h gpio.c gpio.h gptimer.c gptimer.h i2c_lib.c i2c_lib.h interrupt.c interrupt.h ioc.c ioc.h pka.c pka.h rom.h sha256.c sha256.h sleepmode.c sleepmode.h ssi.c ssi.h sys_ctrl.c sys_ctrl.h systick.c systick.h uarthal.c uarthal.h udma.c udma.h watchdog.c watchdog.h
  group bsp/chips/at86rf215
    ../../../bsp/chips/at86rf215/: at86rf215.c at86rf215.h radio_at86rf215.c radio_at86rf215.h
  group bsp/chips/cc2538rf
    ../../../bsp/chips/cc2538rf/: radio_cc2538rf.c radio_cc2538rf.h
  group bsp/chips/si70x
    ../../../bsp/chips/si70x/: si70x.c si70x.h
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h opensensors.c opensensors.h openserial.c openserial.h opentimers.c opentimers.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/openos/: scheduler.c
    ../../../kernel/: scheduler.h
  group openapps
    ../../../openapps/: openapps.c openapps.h
  group openapps/c6t
    ../../../openapps/c6t/: c6t.c c6t.h
  group openapps/cexample
    ../../../openapps/cexample/: cexample.c cexample.h
  group openapps/cinfo
    ../../../openapps/cinfo/: cinfo.c cinfo.h
  group openapps/cinstrument
    ../../../openapps/cinstrument/: cinstrument.c cinstrument.h
  group openapps/cjoin
    ../../../openapps/cjoin/: cjoin.c cjoin.h cojp_cbor.c cojp_cbor.h
  group openapps/cleds
    ../../../openapps/cleds/: cleds.c cleds.h
  group openapps/cmonitor
    ../../../openapps/cmonitor/: cmonitor.c cmonitor.h
  group openapps/csensors
    ../../../openapps/csensors/: csensors.c csensors.h
  group openapps/cstorm
    ../../../openapps/cstorm/: cstorm.c cstorm.h
  group openapps/cwellknow
    ../../../openapps/cwellknown/: cwellknown.c cwellknown.h
  group openapps/opencoap
    ../../../openapps/opencoap/: cborencoder.c cborencoder.h hkdf.c hmac.c opencoap.c opencoap.h openoscoap.c openoscoap.h sha-private.h sha.h sha224-256.c usha.c
  group openapps/rrt
    ../../../openapps/rrt/: rrt.c rrt.h
  group openapps/uecho
    ../../../openapps/uecho/: uecho.c uecho.h
  group openapps/uexpiration
    ../../../openapps/uexpiration/: uexpiration.c uexpiration.h
  group openapps/uexpiration_monitor
    ../../../openapps/uexpiration_monitor/: uexpiration_monitor.c uexpiration_monitor.h
  group openapps/ugateway
    ../../../openapps/ugateway/: ugateway.c ugateway.h
  group openapps/uinject
    ../../../openapps/uinject/: uinject.c uinject.h
  group openapps/userialbridge
    ../../../openapps/userialbridge/: userialbridge.c userialbridge.h
  group openstack
    ../../../openstack/: openstack.c openstack.h
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154_security.c IEEE802154_security.h ieee802154_security_driver.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: msf.c msf.h neighbors.c neighbors.h schedule.c schedule.h sixtop.c sixtop.h
  group openstack/03a-IPHC
    ../../../openstack/03a-IPHC/: frag.c frag.h iphc.c iphc.h openbridge.c openbridge.h
  group openstack/03b-IPv6
    ../../../openstack/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6rpl.c icmpv6rpl.h track.c track.h
  group openstack/04-TRAN
    ../../../openstack/04-TRAN/: openudp.c openudp.h
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
