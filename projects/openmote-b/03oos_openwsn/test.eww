<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\03oos_openwsn.ewp</path>
    </project>
    <batchBuild />
</workspace>
